Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 6d424208-25cf-438c-91a5-e93c62f15636, NumberOfSaves: 1]
File name: 0001
Time: 2026-06-03T11:58:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12959710_F_KM8595-2FR:26I85953_F_12959710_KM8595-2FR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 942 mm; Height: 52 mm; Depth: 526 mm
Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26I85953_F_12959710_KM8595-2FR; sets with these values: 2
